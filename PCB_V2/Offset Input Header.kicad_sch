File: PCB_V2/Offset Input Header.kicad_sch (KiCad schematic)
At the start: 29 parts

Commit message: Tidied schematic and removed old comments
Connections:
- net ~Reset renamed ~{RESET}
